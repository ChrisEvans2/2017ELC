# Keil uVision project elite_test.uvprojx, settings and files
target elite_test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: elite_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,ARM_MATH_CM3
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User;../User/LCD;../User/TOUCH;../User/IIC;../User/24CXX;..\User\FFT;..\User\delay;..\User\DataScope;..\Drivers\STM32F1xx_HAL_Driver;..\Drivers\STM32F1xx_HAL_Driver\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c fsmc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/: startup_stm32f103xe.s
    ../Core/Src/: system_stm32f1xx.c
  group User
    ../User/LCD/: lcd.c
    ../User/IIC/: myiic.c
    ../User/24CXX/: 24cxx.c
    ../User/TOUCH/: touch.c ctiic.c ft5206.c gt9147.c ott2001a.c
    ../User/delay/: delay.c
    ../User/DataScope/: DataScope.c
  group DAP
    ../User/FFT/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
